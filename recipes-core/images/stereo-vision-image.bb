DESCRIPTION = "Stereo Vision image definition for Avnet Zynq Zedboard"
LICENSE = "MIT"

require stereo-vision-image-common.inc

IMAGE_INSTALL += " \
    packagegroup-stereo-vision \
"


